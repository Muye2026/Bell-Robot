#include "display_backend.h"

#include <string.h>

namespace bell_robot {

namespace {
// 字库从 ssd1306_spi.cpp 迁移过来。放在这里是因为它和 SSD1306 没有关系：
// 换成点阵后端后同一套字形要继续用，否则两个后端的字宽会不一致，
// 居中计算就会对不上。列优先，每列低位在上。
constexpr uint8_t kFont5x7[][kGlyphWidth] = {
    {0x00, 0x00, 0x00, 0x00, 0x00}, // space
    {0x00, 0x00, 0x5f, 0x00, 0x00}, // !
    {0x00, 0x07, 0x00, 0x07, 0x00}, // "
    {0x14, 0x7f, 0x14, 0x7f, 0x14}, // #
    {0x24, 0x2a, 0x7f, 0x2a, 0x12}, // $
    {0x23, 0x13, 0x08, 0x64, 0x62}, // %
    {0x36, 0x49, 0x55, 0x22, 0x50}, // &
    {0x00, 0x05, 0x03, 0x00, 0x00}, // '
    {0x00, 0x1c, 0x22, 0x41, 0x00}, // (
    {0x00, 0x41, 0x22, 0x1c, 0x00}, // )
    {0x14, 0x08, 0x3e, 0x08, 0x14}, // *
    {0x08, 0x08, 0x3e, 0x08, 0x08}, // +
    {0x00, 0x50, 0x30, 0x00, 0x00}, // ,
    {0x08, 0x08, 0x08, 0x08, 0x08}, // -
    {0x00, 0x60, 0x60, 0x00, 0x00}, // .
    {0x20, 0x10, 0x08, 0x04, 0x02}, // /
    {0x3e, 0x51, 0x49, 0x45, 0x3e}, // 0
    {0x00, 0x42, 0x7f, 0x40, 0x00}, // 1
    {0x42, 0x61, 0x51, 0x49, 0x46}, // 2
    {0x21, 0x41, 0x45, 0x4b, 0x31}, // 3
    {0x18, 0x14, 0x12, 0x7f, 0x10}, // 4
    {0x27, 0x45, 0x45, 0x45, 0x39}, // 5
    {0x3c, 0x4a, 0x49, 0x49, 0x30}, // 6
    {0x01, 0x71, 0x09, 0x05, 0x03}, // 7
    {0x36, 0x49, 0x49, 0x49, 0x36}, // 8
    {0x06, 0x49, 0x49, 0x29, 0x1e}, // 9
    {0x00, 0x36, 0x36, 0x00, 0x00}, // :
    {0x00, 0x56, 0x36, 0x00, 0x00}, // ;
    {0x08, 0x14, 0x22, 0x41, 0x00}, // <
    {0x14, 0x14, 0x14, 0x14, 0x14}, // =
    {0x00, 0x41, 0x22, 0x14, 0x08}, // >
    {0x02, 0x01, 0x51, 0x09, 0x06}, // ?
    {0x32, 0x49, 0x79, 0x41, 0x3e}, // @
    {0x7e, 0x11, 0x11, 0x11, 0x7e}, // A
    {0x7f, 0x49, 0x49, 0x49, 0x36}, // B
    {0x3e, 0x41, 0x41, 0x41, 0x22}, // C
    {0x7f, 0x41, 0x41, 0x22, 0x1c}, // D
    {0x7f, 0x49, 0x49, 0x49, 0x41}, // E
    {0x7f, 0x09, 0x09, 0x09, 0x01}, // F
    {0x3e, 0x41, 0x49, 0x49, 0x7a}, // G
    {0x7f, 0x08, 0x08, 0x08, 0x7f}, // H
    {0x00, 0x41, 0x7f, 0x41, 0x00}, // I
    {0x20, 0x40, 0x41, 0x3f, 0x01}, // J
    {0x7f, 0x08, 0x14, 0x22, 0x41}, // K
    {0x7f, 0x40, 0x40, 0x40, 0x40}, // L
    {0x7f, 0x02, 0x0c, 0x02, 0x7f}, // M
    {0x7f, 0x04, 0x08, 0x10, 0x7f}, // N
    {0x3e, 0x41, 0x41, 0x41, 0x3e}, // O
    {0x7f, 0x09, 0x09, 0x09, 0x06}, // P
    {0x3e, 0x41, 0x51, 0x21, 0x5e}, // Q
    {0x7f, 0x09, 0x19, 0x29, 0x46}, // R
    {0x46, 0x49, 0x49, 0x49, 0x31}, // S
    {0x01, 0x01, 0x7f, 0x01, 0x01}, // T
    {0x3f, 0x40, 0x40, 0x40, 0x3f}, // U
    {0x1f, 0x20, 0x40, 0x20, 0x1f}, // V
    {0x3f, 0x40, 0x38, 0x40, 0x3f}, // W
    {0x63, 0x14, 0x08, 0x14, 0x63}, // X
    {0x07, 0x08, 0x70, 0x08, 0x07}, // Y
    {0x61, 0x51, 0x49, 0x45, 0x43}, // Z
};
} // namespace

int textWidthPx(const char *text, int scale) {
  if (text == nullptr || scale <= 0) {
    return 0;
  }
  return static_cast<int>(strlen(text)) * kGlyphAdvance * scale;
}

int centeredTextX(const char *text, int scale, int canvasWidth) {
  const int x = (canvasWidth - textWidthPx(text, scale)) / 2;
  return x < 0 ? 0 : x;
}

void DisplayBackend::drawChar(int x, int y, char c, int scale) {
  if (scale <= 0) {
    return;
  }
  if (c >= 'a' && c <= 'z') {
    c = static_cast<char>(c - 'a' + 'A');
  }
  if (c < ' ' || c > 'Z') {
    c = '?';
  }

  const uint8_t *glyph = kFont5x7[c - ' '];
  for (int col = 0; col < kGlyphWidth; ++col) {
    const uint8_t bits = glyph[col];
    for (int row = 0; row < kGlyphHeight; ++row) {
      if ((bits & (1 << row)) == 0) {
        continue;
      }
      for (int dx = 0; dx < scale; ++dx) {
        for (int dy = 0; dy < scale; ++dy) {
          setPixel(x + col * scale + dx, y + row * scale + dy, true);
        }
      }
    }
  }
}

void DisplayBackend::textScaled(int x, int y, int scale, const char *value) {
  if (value == nullptr || scale <= 0) {
    return;
  }
  const int limit = width() - kGlyphWidth * scale;
  for (const char *p = value; *p != '\0' && x <= limit; ++p) {
    drawChar(x, y, *p, scale);
    x += kGlyphAdvance * scale;
  }
}

int DisplayBackend::centeredX(const char *text, int scale) const {
  return centeredTextX(text, scale, width());
}

void DisplayBackend::fillRect(int x, int y, int w, int h, bool on) {
  for (int dy = 0; dy < h; ++dy) {
    for (int dx = 0; dx < w; ++dx) {
      setPixel(x + dx, y + dy, on);
    }
  }
}

void DisplayBackend::drawRectOutline(int x, int y, int w, int h, bool on) {
  if (w <= 0 || h <= 0) {
    return;
  }
  for (int dx = 0; dx < w; ++dx) {
    setPixel(x + dx, y, on);
    setPixel(x + dx, y + h - 1, on);
  }
  for (int dy = 0; dy < h; ++dy) {
    setPixel(x, y + dy, on);
    setPixel(x + w - 1, y + dy, on);
  }
}

} // namespace bell_robot
